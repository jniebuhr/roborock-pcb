# Repository jniebuhr/roborock-pcb

File README.md:

# Roborock CPAP PCB

[![CC BY-NC-SA 4.0][cc-by-nc-sa-shield]][cc-by-nc-sa]

This repository contains a custom PCB for use with the awesome work at [Roborock CPAP](https://github.com/condottab/Roborock-CPAP). The PCB shields the controller board from any back flow that might occur from the brushless controller.

The logic is the same as in the work of [stas2z](https://github.com/stas2z) but reshaped to better fit on the back of the blower while also allowing
for a cooling fan to be added.

## Assembly

## BOM

| Quantity | Designation    | Description          |
|----------|----------------|----------------------|
| 1        | SHOTTKY2       | SS34 Diode           |
| 2        | SHOTTKY1       | SS54 Diode           |
| 1        | ZENER1, ZENER2 | BZT52C5V1S Diode     |
| 1        | R2             | 1206 10kΩ resistor   |
| 1        | R1             | 1206 1kΩ resistor    |
| 2        | J1, J2         | JST XH 3P 2.54mm     |
| 1        | J3             | JST XH 2P 2.54mm     |
| 1        | -              | 4010 cooling fan 24V |
| 2        | -              | M3x6                 |
| 4        | -              | M3x12                |
| 4        | -              | M3 hex nut           |
| 4        | -              | M3 heat set insert   |

## Pinout

The pinout can also be found on the back side of your board and may be different from the most recent version (see note below). 

**Attention:**  
This motor pinout changed in version 0.2.0 due to a rotation of a connector. The same cables will work though since the connector has only been rotated. Refer to the writing on the back of your board.
In version 0.2.0, the 2 pin fan connector was labeled with switched GND and VCC.

## Ordering

In order to support this project, please consider ordering it through my affiliate link.

The gerber and BOM/CPL files can be found under `kicad/`.

## Mounting options

I have also developed some additional mounting options for the Roborock Fan:

* [VzBot 235](mounting/vzbot-235)
* more coming soon...

## Sponsors

The development of this board was kindly supported by [PCBWay](https://www.pcbway.com/) who sent me some prototypes of these boards free of charge.

## License

This work is licensed under a
[Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License][cc-by-nc-sa].

[![CC BY-NC-SA 4.0][cc-by-nc-sa-image]][cc-by-nc-sa]

[cc-by-nc-sa]: http://creativecommons.org/licenses/by-nc-sa/4.0/
[cc-by-nc-sa-image]: https://licensebuttons.net/l/by-nc-sa/4.0/88x31.png
[cc-by-nc-sa-shield]: https://img.shields.io/badge/License-CC%20BY--NC--SA%204.0-lightgrey.svg?style=for-the-badge

## KiCad design kicad/Roborock-CPAP.kicad_pcb

Board: 2 copper layers, 56.0 x 56.0 mm, 30 parts (4 on the bottom side), 6 nets.

Parts:
FAN1: Axial fan 40mm
H1, H2: BoardMount_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopOnly
J1: INPUT; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: MOTOR; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: FAN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1: 1K; R_1206_3216Metric
R2: 10K; R_1206_3216Metric
SBD1: SS54; D_SMA
SBD2: SS34; D_SMA
ZD1, ZD2: BZT52C5V1S; D_SOD-323
kibuzzard-65D0EC22: G***; kibuzzard-65D0EC22
kibuzzard-658C21F4: G***; kibuzzard-658C21F4
kibuzzard-658C22D5: G***; kibuzzard-658C22D5
kibuzzard-658C23C6: G***; kibuzzard-658C23C6
kibuzzard-658C23F8: G***; kibuzzard-658C23F8
kibuzzard-658C47D4: G***; kibuzzard-658C47D4
kibuzzard-658C236E: G***; kibuzzard-658C236E
kibuzzard-658C2196: G***; kibuzzard-658C2196
kibuzzard-658C2284: G***; kibuzzard-658C2284
kibuzzard-658C2303: G***; kibuzzard-658C2303
kibuzzard-658C2312: G***; kibuzzard-658C2312
kibuzzard-658C2324: G***; kibuzzard-658C2324
kibuzzard-658C2360: G***; kibuzzard-658C2360
kibuzzard-658C2410: G***; kibuzzard-658C2410
kibuzzard-659E705B: G***; kibuzzard-659E705B
kibuzzard-659E706B: G***; kibuzzard-659E706B
kibuzzard-659FE8A4: G***; kibuzzard-659FE8A4
kibuzzard-659FE543: G***; kibuzzard-659FE543

Connections:
GND: H1.1, H2.1, H2.2 (1), J1.2, J2.2, J3.2, R2.2, ZD1.2 (A), ZD2.2 (A)
unnamed: R1.2, SBD2.1 (K), ZD2.1 (K)
PWM_IN: J1.3, SBD2.2 (A)
PWM_OUT: J2.3, R1.1, R2.1, ZD1.1 (K)
VCC: J1.1, SBD1.2 (A)
VCC_FUSED: J2.1, J3.1, SBD1.1 (K)

## Commit log

2023-04-16 Update BOM
2023-05-05 Add Nidec mount plate without feet
2023-08-29 Update README.md
    Add Discord
2023-11-07 Component spacing, extra text
    Spaced components a little more evenly so their descriptors are coherent and easy to read
    Added extra clarifying text to the connectors on the left side
2023-11-07 Flood zones (VCC, GND) now follow board outline
2023-11-07 Increase clearance between schottky diode track and screw hole
    using track guidance and fillets
2023-11-07 Extra connector clarification
2023-11-07 Mounting hole pads
    Added appropriate quantity of mounting hole pads
    Also groups the fan & mounting holes
2023-11-07 Board to Roborock holes as THT
    Also renames this group as "Board to Roborock"
2023-11-07 More reference designator fixes
    Fixes some hole reference designators
    Swaps the long designators for shorthands like SBD, ZD
2023-11-07 Add fan connection example
2023-11-07 Resolve ERC (rule checker) errors/warnings
2023-11-07 Rotated fan header right side up, fan example wire colours
    Cooling fan header had pin order 2-1, being reversed. Reversed this along with example fan; Gave example fan wires red/black colouring
2023-11-07 Further refine fan holes
    Oval holes at 1mm lateral-diagonal tolerance
    custom footprint created to edit them separately from the corner holes
    may put the fan holes into a custom footprint that has all four of 'm in one footprint
2023-11-08 More pad optimizations, add colours to nets
2023-11-08 Image renders of PCB
2023-11-11 feat: Change filled zones, replace diode part number, update docs
2023-11-11 Update license
2023-11-11 Fine tune ground plane, rotate connector
    Also adds 0.5mm tracks as the standard track width, and adds a new net class for power tracks that could be useful in the future
2023-11-11 feat: Regenerate screenshots, fix diode number
2023-11-11 fix: Removing backups from git
2023-11-11 Create KiCad .gitignore
    Ignores temporary and backup files made by KiCad
2023-11-11 feat: Add new pinout
2023-11-11 fix: Fix description
2023-11-12 Add 40mm fan
    + remove the four corner pads from the schematic;
    + exclude fan from BOM
    + add fan model (https://grabcad.com/library/40x40x10mm-brushless-axial-fan-1)
2023-11-12 Add Fan1 to schematic, pcb; fix DRC violations of fan etc; update pcb from schematic
2023-11-15 feat: Add vzbot 235 mounting option
2023-12-27 Deleted Unnecesarry files for push
2023-12-27 Added new version files
2023-12-27 Moved files to jlcpcb folder
2023-12-27 Upload gerber files
2023-12-27 Fixed resistor footprint
2023-12-27 changed resistor footprint name in readme
2024-01-12 fix: Rework some labels
2024-01-12 fix: Fix preview images
2024-01-12 fix: Fix README
2024-01-12 fix: Remove pinout image
2024-01-16 feat: Add cad files for mount
2024-02-17 feat: Add new workflows for image generation, pinout
